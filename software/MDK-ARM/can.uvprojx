# Keil uVision project can.uvprojx, settings and files
target can (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: can
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_can.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c main.c stm32f0xx_it.c CO_driver.c eeprom.c application.c CO_OD.c stm32f042_hal_exclude.c
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group CANopenNode
    ../CANopenNode/stack/: CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c crc16-ccitt.c
    ../CANopenNode/: CANopen.c
  group CANopenNode Headers
    ../CANopenNode/stack/: CO_Emergency.h CO_HBconsumer.h CO_NMT_Heartbeat.h CO_PDO.h CO_SDO.h CO_SDOmaster.h CO_SYNC.h crc16-ccitt.h
software components: CMSIS:CORE 5.1.1
